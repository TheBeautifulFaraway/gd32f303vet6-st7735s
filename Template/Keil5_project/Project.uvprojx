# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_HD (6240000::V6.24::ARMCLANG)
  device: GD32F303VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: -std=c11
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\;..\..\Utilities\Third_Party\lvgl-9.1.0;..\..\Utilities\Third_Party
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../: gd32f30x_it.c main.c systick.c lcd.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_dma.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group LVGL
    ../../Utilities/Third_Party/lvgl-9.1.0/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/display/: lv_display.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_image_decoder.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_14.c lv_font_montserrat_24.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/indev/: lv_indev.c lv_indev_scroll.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/layouts/flex/: lv_flex.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/layouts/: lv_layout.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/libs/rle/: lv_rle.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/: lv_init.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/misc/cache/: _lv_cache_lru_rb.c lv_cache.c lv_cache_entry.c lv_image_cache.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_lru.c lv_math.c lv_palette.c lv_rb.c lv_style.c lv_style_gen.c lv_text.c lv_timer.c lv_utils.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/osal/: lv_os_none.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/stdlib/: lv_mem.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/themes/: lv_theme.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/themes/simple/: lv_theme_simple.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/tick/: lv_tick.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/button/: lv_button.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/image/: lv_image.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/label/: lv_label.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/list/: lv_list.c
    ../../Utilities/Third_Party/lvgl-9.1.0/src/widgets/switch/: lv_switch.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.2.0
